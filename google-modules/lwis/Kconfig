## google-modules/lwis/Kconfig
```kconfig
#
# LWIS camera drivers
#

config LWIS
      bool "Drivers under LWIS implementation"
      default n
      help
		    This is the LWIS implementation
```
